# Keil uVision project SRPIP.uvprojx, settings and files
target SRPIP (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SRPIP +hex
  BeforeMake: cmd.exe /C "$Psyscfg_local.bat '$P' ../Core/Src/main.syscfg"
  AfterMake: ./keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;../Core/Inc;C:\ti\mspm0_sdk_2_05_01_00\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_05_01_00\source;..\Middlewares\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_05_01_00\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Application/MDK-ARM
    ./: startup_mspm0g350x_uvision.s
  group Application/User
    ../Core/Src/: main.c main.syscfg
    ../: ti_msp_dl_config.h ti_msp_dl_config.c
  group Middlewares/SeggerRTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
